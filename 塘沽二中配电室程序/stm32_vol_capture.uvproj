# Keil uVision project stm32_vol_capture.uvproj, settings and files
target stm32_vol_capture-triphase (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_vol_capture +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: .\System;.\User\inc;.\Modbus\inc;.\GU900\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/src/: delay.c main.c sys.c usart.c timer.c
  group System
    ./System/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Modbus
    ./Modbus/src/: rs485.c volmeter.c modbus_timer.c
  group GU900
    ./GU900/src/: gu900_uart.c gu900.c
