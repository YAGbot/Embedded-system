# Keil uVision project e-net.uvprojx, settings and files
target 16.WEATHER 天气获取 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: e-net
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\drivers\clk;..\drivers\oled;..\drivers\w5500;..\drivers\delay;..\drivers\uart;..\drivers\spi;..\fwlib\CMSIS;..\fwlib\STM32F10x_StdPeriph_Driver\inc;..\drivers\adc;..\drivers\tmp;..\drivers\rtc;..\drivers\MQTT;..\drivers\rs485;..\drivers\io_check;..\drivers\iwdog
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group example
    ../example/: m_tcp_client.c
  group startup
    ../fwlib/CMSIS/: startup_stm32f10x_md.s
  group cmsis
    ../fwlib/CMSIS/: core_cm3.c system_stm32f10x.c
  group fwlib
    ../fwlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_it.c
  group drivers
    ../drivers/clk/: clk.c
    ../drivers/delay/: delay.c
    ../drivers/spi/: spi.c
    ../drivers/uart/: uart.c
    ../drivers/oled/: oled.c
    ../drivers/tmp/: tmp.c
    ../drivers/adc/: adc.c
    ../drivers/rtc/: rtc.c
    ../drivers/rs485/: rs485.c
    ../drivers/io_check/: iocheck.c
    ../drivers/iwdog/: iwdog.c
  group mikro
    ../drivers/w5500/: arp.c dhcp.c dns.c ftpc.c ftpd.c http_server.c httputil.c json.c md5.c ntp.c ping.c smtp.c socket.c tftp.c ult.c w5500.c
