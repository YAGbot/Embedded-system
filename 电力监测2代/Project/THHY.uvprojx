# Keil uVision project THHY.uvprojx, settings and files
target Camera diagnosis (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: THHY +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\inc;..\Modbus\inc;..\USR_4G\inc;..\DIWEN\inc;..\fatfs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c
  group USER
    ../User/src/: main.c stm32f10x_it.c sys.c delay.c uart.c timer.c at24cxx.c iic.c io_check.c cJSON.c file_system.c malloc.c rtc.c sd_card.c
  group DOC
    ../Doc/: readme.txt
  group Modbus
    ../Modbus/src/: rs485.c volmeter.c
  group USR_4G
    ../USR_4G/src/: usr_4g.c usr_4g_timer.c usr_4g_usart.c
  group DIWEN
    ../DIWEN/src/: diwen.c usart4.c
  group FATFS
    ../fatfs/src/: diskio.c ff.c ffsystem.c ffunicode.c
